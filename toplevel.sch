v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N -270 -240 -230 -240 {lab=#net1
spice_ignore=true}
N -500 -390 -450 -390 {lab=#net2
spice_ignore=true}
N -450 -390 -450 -320 {lab=#net2
spice_ignore=true}
N -230 -240 -230 -110 {lab=#net1
spice_ignore=true}
N -550 -210 -550 -110 {lab=Iin
spice_ignore=true}
N -550 -210 -500 -210 {lab=Iin
spice_ignore=true}
N -360 -110 -230 -110 {lab=#net1
spice_ignore=true}
N -550 -110 -420 -110 {lab=Iin
spice_ignore=true}
N -360 -50 -230 -50 {lab=#net1
spice_ignore=true}
N -230 -110 -230 -50 {lab=#net1
spice_ignore=true}
N -550 -50 -420 -50 {lab=Iin
spice_ignore=true}
N -550 -110 -550 -50 {lab=Iin
spice_ignore=true}
N -230 -240 -180 -240 {lab=#net1
spice_ignore=true}
N -590 -210 -550 -210 {lab=Iin
spice_ignore=true}
N -590 -320 -530 -320 {lab=#net3
spice_ignore=true}
N -530 -320 -530 -260 {lab=#net3
spice_ignore=true}
N -530 -260 -500 -260 {lab=#net3
spice_ignore=true}
N -240 -570 -240 -550 {lab=VDD}
N 920 -240 990 -240 {lab=#net1}
N 990 -240 990 -90 {lab=#net1}
N 610 -230 680 -230 {lab=#net2}
N 610 -260 680 -260 {lab=#net3}
N 610 -430 610 -280 {lab=#net3}
N 920 -260 990 -260 {lab=#net4}
N 990 -430 990 -260 {lab=#net4}
N 990 -260 1100 -260 {lab=#net4}
N 990 -240 1070 -240 {lab=#net1}
N 710 -400 710 -340 {lab=Vb1}
N 730 -380 730 -340 {lab=Vb2}
N 830 -430 990 -430 {lab=#net4}
N 610 -430 770 -430 {lab=#net3}
N 830 -90 990 -90 {lab=#net1}
N 610 -90 770 -90 {lab=#net2}
N 570 -260 610 -260 {lab=#net3}
N 570 -230 610 -230 {lab=#net2}
N 470 -230 510 -230 {lab=Vinp}
N 610 -280 610 -260 {lab=#net3}
N 610 -230 610 -90 {lab=#net2}
N 750 -370 750 -340 {lab=Vb3}
N 770 -360 770 -340 {lab=Vb4}
N 860 -400 860 -300 {lab=#net5}
N 860 -400 920 -400 {lab=#net5}
N -770 -620 -770 -590 {lab=Iin
spice_ignore=true}
N -770 -590 -710 -590 {lab=Iin
spice_ignore=true}
N -770 -530 -710 -530 {lab=0
spice_ignore=true}
N -90 -590 -90 -560 {lab=Vb1
}
N -100 -590 -90 -590 {lab=Vb1
}
N 0 -590 0 -560 {lab=Vb2
}
N -10 -590 0 -590 {lab=Vb2
}
N 80 -580 80 -550 {lab=Vb3
}
N 70 -580 80 -580 {lab=Vb3
}
N 180 -570 180 -540 {lab=Vb4
}
N 170 -570 180 -570 {lab=Vb4
}
N 1970 -430 1970 -330 {lab=VDD}
N 2010 -400 2010 -330 {lab=Vb1}
N 2050 -400 2050 -330 {lab=Vb2}
N 2090 -400 2090 -330 {lab=Vb3}
N 2130 -400 2130 -330 {lab=Vb4}
N 2170 -420 2170 -330 {lab=#net6}
N 2170 -420 2240 -420 {lab=#net6}
N -140 160 -80 160 {lab=#net13
spice_ignore=true}
N -80 120 -80 160 {lab=#net13
spice_ignore=true}
N -140 60 -140 120 {lab=#net14
spice_ignore=true}
N 470 -260 510 -260 {lab=Vinn}
N 370 -260 370 -230 {lab=Vinn
}
N 430 -100 430 -70 {lab=#net7
}
N 430 -230 470 -230 {lab=Vinp}
N 370 -260 470 -260 {lab=Vinn}
N 3220 -370 3220 -310 {lab=VDD}
N 3360 -240 3430 -240 {lab=Vout}
N 2230 -230 2290 -230 {lab=Voutn}
N 3070 -270 3130 -270 {lab=Voutn}
N 2230 -270 2270 -270 {lab=Voutp}
N 3050 -220 3130 -220 {lab=Voutp}
N 2690 -270 3010 -270 {lab=Voutp}
N 3010 -270 3010 -220 {lab=Voutp}
N 3070 -270 3070 -250 {lab=Voutn}
N 1100 -260 1100 -240 {lab=#net4}
N 1100 -240 1220 -240 {lab=#net4}
N 1070 -270 1220 -270 {lab=#net1}
N 1070 -270 1070 -240 {lab=#net1}
N 1750 -250 1820 -250 {lab=#net8}
N 1820 -250 1820 -100 {lab=#net8}
N 1440 -240 1510 -240 {lab=#net9}
N 1440 -270 1510 -270 {lab=#net10}
N 1440 -440 1440 -290 {lab=#net10}
N 1750 -270 1820 -270 {lab=#net11}
N 1820 -440 1820 -270 {lab=#net11}
N 2600 -250 2680 -250 {lab=Voutn}
N 1540 -410 1540 -350 {lab=Vb1}
N 1560 -390 1560 -350 {lab=Vb2}
N 1660 -440 1820 -440 {lab=#net11}
N 1440 -440 1600 -440 {lab=#net10}
N 1660 -100 1820 -100 {lab=#net8}
N 1440 -100 1600 -100 {lab=#net9}
N 1400 -270 1440 -270 {lab=#net10}
N 1400 -240 1440 -240 {lab=#net9}
N 1300 -240 1340 -240 {lab=#net4}
N 1440 -290 1440 -270 {lab=#net10}
N 1440 -240 1440 -100 {lab=#net9}
N 1580 -380 1580 -350 {lab=Vb3}
N 1600 -370 1600 -350 {lab=Vb4}
N 1690 -410 1690 -310 {lab=#net12}
N 1690 -410 1750 -410 {lab=#net12}
N 1300 -270 1340 -270 {lab=#net1}
N 2600 -270 2690 -270 {lab=Voutp}
N 2680 -250 2690 -250 {lab=Voutn}
N 2690 -250 3070 -250 {lab=Voutn}
N 3010 -220 3050 -220 {lab=Voutp}
N 1820 -270 1910 -270 {lab=#net11}
N 1820 -250 1910 -250 {lab=#net8}
N 1910 -250 1910 -230 {lab=#net8}
N 2270 -270 2600 -270 {lab=Voutp}
N 2290 -250 2290 -230 {lab=Voutn}
N 2290 -250 2600 -250 {lab=Voutn}
N 1220 -270 1300 -270 {lab=#net1}
N 1220 -240 1300 -240 {lab=#net4}
N 370 -130 370 -100 {lab=#net13}
N 370 -230 370 -190 {lab=Vinn}
N 430 -230 430 -160 {lab=Vinp}
C {isource.sym} -500 -360 0 0 {name=I0 value=25u
spice_ignore=true}
C {gnd.sym} -500 -330 0 0 {name=l1 lab=0
spice_ignore=true}
C {vdd.sym} -420 -310 0 0 {name=l3 lab=VDD
spice_ignore=true}
C {gnd.sym} -420 -170 0 0 {name=l4 lab=0
spice_ignore=true}
C {vsource.sym} -240 -520 0 0 {name=V1 value=3.3 savecurrent=false}
C {vdd.sym} -240 -570 0 0 {name=l2 lab=VDD}
C {gnd.sym} -240 -490 0 0 {name=l11 lab=0}
C {lab_pin.sym} -590 -210 0 0 {name=p1 sig_type=std_logic lab=Iin
spice_ignore=true}
C {res.sym} -390 -110 1 0 {name=R1
value=100k
footprint=1206
device=resistor
m=1
spice_ignore=true}
C {capa.sym} -390 -50 1 0 {name=C1
m=1
value=2p
footprint=1206
device="ceramic capacitor"
spice_ignore=true}
C {gnd.sym} -590 -260 0 0 {name=l5 lab=0
spice_ignore=true}
C {vsource.sym} -590 -290 0 0 {name=V2 value=1.7 savecurrent=false
spice_ignore=true}
C {chipathon-2026-ppg/jz_tia/two_stage_miller_larger_forsym.sym} -420 -240 0 0 {name=x1
spice_ignore=true}
C {chipathon-2026-ppg/ps-filters/hpf.sym} -300 140 0 0 {name=X2
spice_ignore=true}
C {lab_pin.sym} 730 -380 3 1 {name=p2 sig_type=std_logic lab=Vb2
}
C {lab_pin.sym} 710 -400 0 0 {name=p4 sig_type=std_logic lab=Vb1
}
C {vdd.sym} 800 -320 0 0 {name=l7 lab=VDD}
C {isource.sym} 920 -370 0 0 {name=I1 value=25u
}
C {gnd.sym} 800 -180 0 0 {name=l8 lab=0
}
C {res.sym} 800 -430 1 0 {name=R2
value=158k
footprint=1206
device=resistor
m=1}
C {res.sym} 800 -90 1 0 {name=R3
value=158k
footprint=1206
device=resistor
m=1}
C {res.sym} 540 -230 1 0 {name=R4
value=5k
footprint=1206
device=resistor
m=1}
C {res.sym} 540 -260 1 0 {name=R5
value=5k
footprint=1206
device=resistor
m=1}
C {chipathon-2026-ppg/jz_fda2/foldedcasc_cmfb_forsym.sym} 810 -50 0 0 {name=x3}
C {lab_pin.sym} 770 -360 0 1 {name=p7 sig_type=std_logic lab=Vb4
}
C {lab_pin.sym} 750 -370 3 1 {name=p8 sig_type=std_logic lab=Vb3
}
C {gnd.sym} 920 -340 0 0 {name=l9 lab=0
}
C {chipathon-2026-ppg/ps-filters/lpf.sym} 2070 -250 0 0 {name=X4}
C {gnd.sym} -770 -530 0 0 {name=l31 lab=0
spice_ignore=true}
C {lab_pin.sym} -770 -620 0 0 {name=p11 sig_type=std_logic lab=Iin
spice_ignore=true}
C {capa.sym} -710 -560 0 0 {name=C2
m=1
value=11p
footprint=1206
device="ceramic capacitor"
spice_ignore=true}
C {isource.sym} -770 -560 2 0 {name=I2 value="SIN(0.1u 1n 1)"
spice_ignore=true}
C {code_shown.sym} -580 -660 0 0 {name=SPICE1 only_toplevel=false value=".option savecurrents
.save all
.ic v(Vout)=0
.control
op
write oppoints.raw
tran 0.1 2s
plot Vout
plot Vinp Vinn
plot Voutp Voutn
.endc"
}
C {vsource.sym} -90 -530 0 0 {name=V9 value=1.4 savecurrent=false
}
C {gnd.sym} -90 -500 0 0 {name=l14 lab=0
}
C {lab_pin.sym} -100 -590 0 0 {name=p14 sig_type=std_logic lab=Vb1
}
C {vsource.sym} 0 -530 0 0 {name=V10 value=1.6 savecurrent=false
}
C {gnd.sym} 0 -500 0 0 {name=l15 lab=0
}
C {lab_pin.sym} -10 -590 0 0 {name=p15 sig_type=std_logic lab=Vb2
}
C {vsource.sym} 80 -520 0 0 {name=V11 value=0.8 savecurrent=false
}
C {gnd.sym} 80 -490 0 0 {name=l16 lab=0
}
C {lab_pin.sym} 70 -580 0 0 {name=p16 sig_type=std_logic lab=Vb3
}
C {vsource.sym} 180 -510 0 0 {name=V12 value=2.3 savecurrent=false
}
C {gnd.sym} 180 -480 0 0 {name=l17 lab=0
}
C {lab_pin.sym} 170 -570 0 0 {name=p17 sig_type=std_logic lab=Vb4
}
C {gnd.sym} 2070 -170 0 0 {name=l6 lab=0
}
C {lab_pin.sym} 2010 -400 0 0 {name=p5 sig_type=std_logic lab=Vb1
}
C {lab_pin.sym} 2050 -400 3 1 {name=p6 sig_type=std_logic lab=Vb2
}
C {lab_pin.sym} 2090 -400 3 1 {name=p12 sig_type=std_logic lab=Vb3
}
C {lab_pin.sym} 2130 -400 0 1 {name=p13 sig_type=std_logic lab=Vb4
}
C {isource.sym} 2240 -390 0 0 {name=I3 value=25u
}
C {gnd.sym} 2240 -360 0 0 {name=l12 lab=0
}
C {vsource.sym} 370 -70 0 0 {name=V3 value="SIN(1.7 -1m 1)" savecurrent=false
}
C {gnd.sym} 370 -40 0 0 {name=l13 lab=0
}
C {vsource.sym} 430 -40 0 0 {name=V4 value="SIN(1.7 1m 1)" savecurrent=false
}
C {gnd.sym} 430 -10 0 0 {name=l18 lab=0
}
C {chipathon-2026-ppg/comparator/schematic-design/comp_forsym.sym} 3230 -240 0 0 {name=x5}
C {gnd.sym} 3220 -160 0 0 {name=l20 lab=0
}
C {lab_pin.sym} 3430 -240 0 1 {name=p3 sig_type=std_logic lab=Vout
}
C {vdd.sym} 1970 -430 0 0 {name=l10 lab=VDD}
C {vdd.sym} 3220 -370 0 0 {name=l19 lab=VDD}
C {code.sym} 300 -640 0 0 {name=MODELS only_toplevel=true  
format="tcleval( @value )" 
value="
.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice typical
.lib $::180MCU_MODELS/smbb000149.ngspice typical
"}
C {lab_pin.sym} 480 -230 1 1 {name=p9 sig_type=std_logic lab=Vinp
}
C {lab_pin.sym} 450 -260 3 1 {name=p10 sig_type=std_logic lab=Vinn
}
C {lab_pin.sym} 2680 -250 1 1 {name=p18 sig_type=std_logic lab=Voutn
}
C {lab_pin.sym} 2760 -270 3 1 {name=p19 sig_type=std_logic lab=Voutp
}
C {lab_pin.sym} 1560 -390 3 1 {name=p24 sig_type=std_logic lab=Vb2
}
C {lab_pin.sym} 1540 -410 0 0 {name=p25 sig_type=std_logic lab=Vb1
}
C {vdd.sym} 1630 -330 0 0 {name=l24 lab=VDD}
C {isource.sym} 1750 -380 0 0 {name=I5 value=25u
}
C {gnd.sym} 1630 -190 0 0 {name=l25 lab=0
}
C {res.sym} 1630 -440 1 0 {name=R10
value=158k
footprint=1206
device=resistor
m=1}
C {res.sym} 1630 -100 1 0 {name=R11
value=158k
footprint=1206
device=resistor
m=1}
C {res.sym} 1370 -240 1 0 {name=R12
value=5k
footprint=1206
device=resistor
m=1}
C {res.sym} 1370 -270 1 0 {name=R13
value=5k
footprint=1206
device=resistor
m=1}
C {chipathon-2026-ppg/jz_fda2/foldedcasc_cmfb_forsym.sym} 1640 -60 0 0 {name=x7}
C {lab_pin.sym} 1600 -370 0 1 {name=p26 sig_type=std_logic lab=Vb4
}
C {lab_pin.sym} 1580 -380 3 1 {name=p27 sig_type=std_logic lab=Vb3
}
C {gnd.sym} 1750 -350 0 0 {name=l26 lab=0
}
C {vsource.sym} 430 -130 0 0 {name=V5 value="SIN(0 0.1m 15)" savecurrent=false
}
C {vsource.sym} 370 -160 0 0 {name=V6 value="SIN(0 -0.1m 15)" savecurrent=false
}
